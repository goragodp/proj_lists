# Keil uVision project STM32L152-TRAINING.uvprojx, settings and files
target STM32L152-DISC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152-TRAINING
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L152xB
  c include: ..\Inc;..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi_ex.c
  group Application/User
    ../Src/: EX1-GPIO.c EX2-ADC.c EX3-DAC.c EX4-EXTI_GPIO.c EX5-Timer.c EX5-Timer-INT.c EX6-PWM.c EX7-UART.c EX7-UART-DMA.c EX8-SPI-Polling_MASTER.c EX8-SPI-DMA_MASTER.c EX9-I2C_MASTER.c stm32l1xx_hal_msp.c stm32l1xx_it.c
